# IAR project wireless.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_BAND_433; USE_MODEM_LORA
  ICCARM.CCIncludePath2: ..\..\; ..\..\stack\; ..\..\system\; ..\..\system\crypto; ..\..\sys_arch\; ..\..\sys_arch\include\; ..\..\sys_arch\portable\IAR\ARM_CM3\; ..\..\platform\drivers\; ..\..\platform\stm32L151x\; ..\..\platform\stm32L151x\lib\inc\; ..\..\apps\; ..\..\common\; ..\..\common\radio\; ..\..\common\radio\sx1278\; ..\..\apps\wireless
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\apps\
  OBJCOPY.OOCOutputFile: wireless.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: wireless.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 输出固件 (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32l151xB.icf
  group (top)
    ./: stm32l151xB.icf
  group apps
    ../../apps/: FreeRTOSConfig.h main.c
  group apps/wireless
    ../../apps/wireless/: app.c app.h lora_app.c lora_app.h lora_cfg.h wireless_config.c wireless_config.h
  group common
    ../../common/: crc.c crc.h data_type_def.h debug.c debug.h lib.h mlist.c mlist.h serial.c serial.h sqqueue.c sqqueue.h
  group common/radio
    ../../common/radio/: radio.h
  group common/radio/sx1278
    ../../common/radio/sx1278/: sx1278.c sx1278.h sx1278Regs-Fsk.h sx1278Regs-LoRa.h
  group platform/drivers
    ../../platform/drivers/: board.c board.h gpio-board.c gpio-board.h i2c-board.c i2c-board.h LoRaMac-board.h pinName-board.h pinName-ioe.h rtc-board.c rtc-board.h spi-board.c spi-board.h sx1278-board.c sx1278-board.h timer-board.c timer-board.h uart-board.c uart-board.h
  group platform/stm32L151x
    ../../platform/stm32L151x/: startup_stm32l1xx_md.s stm32l1xx.h stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c system_stm32l1xx.h
  group platform/stm32L151x/lib
    ../../platform/stm32L151x/lib/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group stack
    ../../stack/: stack.c stack.h
  group stack/common
    ../../stack/common/: pbuf.c pbuf.h prim.h sbuf.c sbuf.h
  group stack/mac
    ../../stack/mac/: LoRaMac-api-v3.c LoRaMac-api-v3.h LoRaMac.c LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacTest.h
  group sys_arch
    ../../sys_arch/: event_groups.c list.c osel_arch.h queue.c tasks.c timers.c
  group sys_arch/include
    ../../sys_arch/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group sys_arch/portable
    ../../sys_arch/portable/MemMang/: heap_2.c
    ../../sys_arch/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group system
    ../../system/: delay.c delay.h eeprom.c eeprom.h fifo.c fifo.h flash.c flash.h gpio.c gpio.h i2c.c i2c.h serial.h spi.h timer.c timer.h uart.c uart.h
  group system/crypto
    ../../system/crypto/: aes.c aes.h cmac.c cmac.h
